Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-08-25T14:48:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.90.15 - Exporter 21.1.90.15 - Alternate UI 21.1.90.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 25 14:48:08 2024 * Host: DCreative * Database: C:\Users\chatp\AppData\Local\Temp\3211e499-1c11-4351-9318-3c50579a1372\a1aeb545-2b55-418b-a52c-4559e08f3f9d\ifc * Database version: 5507 * Database creation date: Sun Aug 25 14:48:07 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 25 14:48:08 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 25 14:48:08 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcBuildingElementProxy: FFAS8101-AD0500BT0_REVIT:Integral Foam & Water Faucet-AC/DC, FFAS8101-AD0500BT0_REVIT:Integral Foam & Water Faucet-AC/DC:348509
In: Level 1
Type - Material: Brass, <Unnamed>, American Standard - Brass - Chrome
Type - Pset_BuildingElementProxyCommon - Reference: Integral Foam & Water Faucet-AC/DC
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Integral Foam & Water Faucet-AC/DC
Type - Pset_ProvisionForVoid - Width: 40 mm; Height: 220 mm; Depth: 155 mm
Material: American Standard - Brass - Chrome
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_348509
Description: Flow; FlowDirection: SOURCE
